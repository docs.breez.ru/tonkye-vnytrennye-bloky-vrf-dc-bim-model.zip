Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-11-06T15:11:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Nov 06 15:11:38 2020 * Host: GVIZITI-RO-LE * Database: C:\Users\gviziti\AppData\Local\Temp\{401D1712-0A51-4611-9F07-57B35E69657E}\ifc * Database version: 5507 * Database creation date: Fri Nov 06 15:11:37 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Nov 06 15:11:37 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Nov 06 15:11:37 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcUnitaryEquipment: AVE-12HCFRL, HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVE-05-24HCFRL_INT-EN:AVE-12HCFRL:9231
In: Level 1
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 166-166-166, Color RGB 100-100-100, Color RGB 245-245-245, Color RGB 187-185-183, Color RGB 168-128-048
Type - Dimensions - Depth: 447 mm; Drain Diameter: 32 mm; Duct Height 1: 167.5 mm; Duct Height 2: 128.5 mm; Duct Width 1: 573 mm; Duct Width 2: 537 mm; Height: 192 mm; Refrigerant Gas Diameter: 12.7 mm; Refrigerant Liquid Diameter: 6.35 mm; Width: 700 mm
Type - Electrical - Cooling Power Input (kW): 0.07; Cooling Running Current (A): 0.35; Heating Power Input (kW): 0.07; Heating Running Current (A): 0.35; Hertz: 50 Hz; Motor Power (W): 29 W; Phase: 1; Voltage: 230 V
Type - Electrical - Loads - Power: 0 W
Type - Identity Data - Article Description: Low-height ceiling ducted type; Article Type: AVE-12HCFRL; Base Family Version: 12.20; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Low-height ceiling ducted type; EMCS Version: 4.0; ETIM Article Class: EC011580; Family Version: 12.20; Manufacturer: Hisense; Manufacturer Art. No.: AVE-12HCFRL; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; Model: AVE-12HCFRL; OmniClass Number: 23.75.10.24.21.27; OmniClass Title: Unitary Air Conditioning Equipment; Product Line: AC Low-Height; Revit Version: 2018; Type Name: AVE-12HCFRL; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Dark Grey: Color RGB 100-100-100; Grey: Color RGB 166-166-166; Light Grey: Color RGB 187-185-183; White: Color RGB 245-245-245; Yellow: Color RGB 168-128-048
Type - Mechanical - Cooling Capacity (kW): 3.6; Heating Capacity (kW): 4
Type - Mechanical - Loads - Airflow Rate (m3/min): 5.7; External Static Pressure (Pa): 10; Sound Pressure Level (dB(A)): 25; Unit Weight (kg): 17
Type - Other - Category: Mechanical Equipment; Distance Between Brackets: 375 mm; Family Name: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVE-05-24HCFRL_INT-EN; Gas Connection Geometry: 16.7 mm; Liquid Connection Geometry: 10.35 mm
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 1.1296 m2; Ceiling Offset: 10 mm; Volume: 0.0583125 m3
Identity Data - Mark: 1
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Hydronic Supply,Sanitary,Power,Supply Air,Return Air
Mechanical - Flow - Flow 1: 0 m3/s; Flow 2: 0 m3/s
Other - Family: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVE-05-24HCFRL_INT-EN: AVE-12HCFRL; Family and Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVE-05-24HCFRL_INT-EN: AVE-12HCFRL; Offset from Ceiling Safe: 10 mm; Service Space Length Safe: 450 mm; Service Space Width Safe: 450 mm; Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVE-05-24HCFRL_INT-EN: AVE-12HCFRL; Type Id: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVE-05-24HCFRL_INT-EN: AVE-12HCFRL
Phasing - Phase Created: New Construction
Visibility - Service Space: no; Service Space Length: 450 mm; Service Space Width: 450 mm
